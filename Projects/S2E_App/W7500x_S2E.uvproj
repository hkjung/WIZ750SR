# Keil uVision project W7500x_S2E.uvproj, settings and files
target W7500x_S2E_App (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: W7500x_S2E_App +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: w7500_s2e_app_gen_production_hex2bin.bat
  c flags: Optim=4
  c define: CORTEX_M0 USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS\Device\WIZnet\W7500\Include;..\..\Libraries\W7500x_stdPeriph_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\WIZnet\W7500\Source\ARM;.\src;..\..\ioLibrary\Ethernet;..\..\ioLibrary\Internet\DHCP;..\..\ioLibrary\Internet\DNS;..\..\ioLibrary\MDIO;..\..\ioLibrary\Application\loopback;.\src\Configuration;.\src\PlatformHandler;.\src\Serial_to_Ethernet;.\src\Callback;.\src\MQTTPacket\src;.\src\Thingplus;.\src\cJSON
  memory RVCT4: ROM 0x7000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group MDK-ARM
    ../../Libraries/CMSIS/Device/WIZnet/W7500/Source/ARM/: startup_W7500x.s
  group CMSIS
    ../../Libraries/CMSIS/Device/WIZnet/W7500/Source/: system_W7500x.c
  group W7500_Periphs
    ../../Libraries/W7500x_stdPeriph_Driver/src/: W7500x_adc.c W7500x_dualtimer.c W7500x_exti.c W7500x_gpio.c W7500x_pwm.c W7500x_ssp.c W7500x_uart.c W7500x_wdt.c W7500x_wztoe.c W7500x_crg.c W7500x_rng.c W7500x_dma.c
  group ioLibrary
    ../../ioLibrary/Ethernet/: socket.c wizchip_conf.c
    ../../ioLibrary/MDIO/: W7500x_miim.c
    ../../ioLibrary/Internet/DHCP/: dhcp.c
    ../../ioLibrary/Internet/DNS/: dns.c
    ../../ioLibrary/Application/loopback/: loopback.c
  group Callback
    ./src/Callback/: dhcp_cb.c
  group User_Main
    ./src/: W7500x_it.c retarget.c main.c W7500x_board.c mqttHandler.c MQTTClient.c MQTTClient.h
  group Serial_to_Ethernet
    ./src/Serial_to_Ethernet/: seg.c
  group Configuration
    ./src/Configuration/: ConfigData.c segcp.c util.c
  group PlatformHandler
    ./src/PlatformHandler/: flashHandler.c storageHandler.c timerHandler.c uartHandler.c deviceHandler.c gpioHandler.c eepromHandler.c i2cHandler.c
  group MQTT_Paho
    ./src/MQTTPacket/src/: MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
  group Thingplus
    ./src/Thingplus/: thingplus.c
  group cJSON
    ./src/cJSON/: cJSON.c
